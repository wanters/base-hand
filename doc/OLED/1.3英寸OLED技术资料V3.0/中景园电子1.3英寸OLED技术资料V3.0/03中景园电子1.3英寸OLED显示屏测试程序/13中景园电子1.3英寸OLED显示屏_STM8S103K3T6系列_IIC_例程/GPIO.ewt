<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <group>
      <name>OLED</name>
      <file>
        <name>$PROJ_DIR$\OLED_SRC\oled.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_it.h</name>
    </file>
  </group>
</project>


